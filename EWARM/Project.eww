<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F746Testing.ewp</path>
  </project>
  <batchBuild />
</workspace>
